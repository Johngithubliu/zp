# Keil uVision project dlbzj.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: dlbzj +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\;.\modbus;.\modbus\include;.\modbus\port;.\modbus\ascii;.\modbus\rtu
  group Source Group 1
    ./: readme.txt STARTUP.A51 main.c Conf_tny.A51 mydefine.h stc12cxx.h SERIAL.C common.h 24lc16.c 24lc16.h
  group modbus
    ./Modbus/: mb.c
    ./Modbus/rtu/: mbcrc.c mbrtu.c
    ./Modbus/port/: porttimer.c portevent.c portserial.c
    ./Modbus/functions/: mbfuncholding.c mbutils.c mbfuncinput.c
